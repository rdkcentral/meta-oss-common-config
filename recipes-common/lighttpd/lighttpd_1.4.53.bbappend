FILESEXTRAPATHS:prepend:="${THISDIR}/${PN}:"

SRC_URI:append += " file://lighttpd_jst.conf_broadband "
SRC_URI:append += " file://lighttpd_php.conf_broadband "


